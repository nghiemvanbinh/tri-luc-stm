# Keil uVision project thu_stm.uvprojx, settings and files
target thu_stm (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F207VGTx STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.10.0
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF)  CLOCK(25000000) CPUTYPE("Cortex-M3") TZ
  output: thu_stm +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F207xx
  c misc: --C99 --cpp11
  c include: ../Core/Inc;../Drivers/STM32F2xx_HAL_Driver/Inc;../Drivers/STM32F2xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F2xx/Include;../Drivers/CMSIS/Include;../SimpleKalmanFilter-master/SimpleKalmanFilter-master/src
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f207xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c usart.c stm32f2xx_it.c stm32f2xx_hal_msp.c
  group Drivers/STM32F2xx_HAL_Driver
    ../Drivers/STM32F2xx_HAL_Driver/Src/: stm32f2xx_hal_adc.c stm32f2xx_hal_adc_ex.c stm32f2xx_hal.c stm32f2xx_hal_rcc.c stm32f2xx_hal_rcc_ex.c stm32f2xx_hal_cortex.c stm32f2xx_hal_flash.c stm32f2xx_hal_flash_ex.c stm32f2xx_hal_pwr.c stm32f2xx_hal_pwr_ex.c stm32f2xx_hal_gpio.c stm32f2xx_hal_dma.c stm32f2xx_hal_dma_ex.c stm32f2xx_hal_exti.c stm32f2xx_hal_tim.c stm32f2xx_hal_tim_ex.c stm32f2xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f2xx.c
  group lib_kalman
    ../SimpleKalmanFilter-master/SimpleKalmanFilter-master/src/: SimpleKalmanFilter.cpp
software components: CMSIS:CORE 4.3.0
